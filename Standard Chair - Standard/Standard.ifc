Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:48:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:48:32 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{C4F678F7-82CF-4460-AC0B-E1495FBAB25F}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:48:32 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:48:32 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:48:32 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Standard, CONV_Vitra_DmstcChrs_Standard:Standard:406403
In: Level 1
Material: 12 deep black powder-coated (textured), Glide black, Wood oak seat
Pset_ManufacturerTypeInformation - ModelReference: 21043500; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.952 m2; Volume: 0.168756 m3
Materials and Finishes - ChairMainMaterial: Wood oak seat; ChairSecondaryMaterial: 12 deep black powder-coated (textured)
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Standard: Standard; Family and Type: CONV_Vitra_DmstcChrs_Standard: Standard; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Standard: Standard; Type Id: CONV_Vitra_DmstcChrs_Standard: Standard; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Standard; ConvergoRefNr: 0089-1812-0140-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Standard Chair by Jean Prouve has evolved into one of the most famous classics of the French 'constructeur'.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: Standard; Cost: 0; Description: The Standard Chair by Jean Prouve has evolved into one of the most famous classics of the French 'constructeur'. The seat and backrest of this understated, iconic chair are available in various types of wood, and the metal frame comes in different colours.; Designer: Jean Prouve; Manufacturer: Vitra; Model: Standard; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191390/storage/master/download/FS_Standard-EN_Preview-Single-Page.pdf; Type Name: Standard; URL: https://www.vitra.com/en-un/living/product/details/standard
Materials and Finishes(Type) - ChairTertiaryMaterial: Glide black
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Standard; Features: n/a; Finish: Seat and backrest: oak (natural or dark finish) or walnut (black pigmented finish). Base: bent sheet steel and tubular steel, powder-coated finish (smooth).; Grade: n/a; Material: Wood & steel; ModelNumber: n/a; ModelReference: 21043500; Name: DmstcChrs_Standard; ReplacementCost: n/a; Shape: Sculptured; Size: 420x490x820 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
